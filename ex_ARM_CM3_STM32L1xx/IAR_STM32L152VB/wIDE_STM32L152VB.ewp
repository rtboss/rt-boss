# IAR project wIDE_STM32L152VB.ewp, settings and files
configuration STM32L152VB (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L1XX_MD
  ICCARM.CCIncludePath2: ..\; ..\..\Boss
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wIDE_STM32L152VB.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l152xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boss files
    ../../Boss/: Boss.c Boss_Flag.c Boss_Mem.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM3_IAR.c Boss_CPU_ARM_CM3_IAR_asm.s
  group Source files
    ../../: Main.c
    ./: startup_stm32l1xx_md.s
    ../: system_stm32l1xx.c
