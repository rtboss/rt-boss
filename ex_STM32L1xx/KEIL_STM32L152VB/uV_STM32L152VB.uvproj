# Keil uVision project uV_STM32L152VB.uvproj, settings and files
target STM32L152VB (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uV_STM32L152VB
  c flags: Optim=1
  c define: STM32L1XX_MD
  c include: ..\..\Boss;..\..\ex_STM32L1xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Boss files
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM3_Keil.c
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_Tmr.c Boss_SPY.c
  group Source files
    ./: startup_stm32l1xx_md.s
    ../: system_stm32l1xx.c Main_ex0_STM32L1xx.c
