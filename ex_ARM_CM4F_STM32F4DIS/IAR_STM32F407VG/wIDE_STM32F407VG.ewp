# IAR project wIDE_STM32F407VG.ewp, settings and files
configuration STM32F407VG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\..\Boss
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: wIDE_STM32F407VG.out
  ILINK.IlinkIcfFile: stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boss files
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM4F_IAR.c Boss_CPU_ARM_CM4F_IAR_asm.s
  group Source files
    ../: Main_ex0_STM32F4DIS.c system_stm32f4xx.c
    ./: startup_stm32f40xx.s
