<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\wIDE_STM32F407VG.ewp</path>
  </project>
  <batchBuild/>
</workspace>


