# Keil uVision project uV_STM32F407VG.uvproj, settings and files
target STM32F407VG (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uV_STM32F407VG
  c flags: Optim=1
  c define: STM32F4XX
  c include: ..\;..\..\Boss
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Boss files
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM4F_Keil.c
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
  group Source files
    ./: startup_stm32f40xx.s
    ../: system_stm32f4xx.c
    ../../: Main.c
