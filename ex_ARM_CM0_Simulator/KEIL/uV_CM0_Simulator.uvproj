# Keil uVision project uV_CM0_Simulator.uvproj, settings and files
target CM0_Sim (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uV_CM0_Simulator
  c flags: Optim=1
  c include: ..\;..\..\Boss
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Boss files
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM0_Keil.c
    ../../Boss/: Boss.c Boss_Flag.c Boss_Mem.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
  group Source files
    ./: startup_ARMCM0.s
    ../: system_ARMCM0.c
    ../../: Main.c
