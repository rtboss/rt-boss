# Keil uVision project uV_STM32F051R8.uvproj, settings and files
target STM32F0DIS (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: uV_STM32F051R8 +hex
  c flags: Optim=1
  c include: ..\;..\..\Boss
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Boss files
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM0_Keil.c
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
  group Source files
    ./: startup_stm32f0xx.s
    ../: system_stm32f0xx.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c
    ../../: Main.c
