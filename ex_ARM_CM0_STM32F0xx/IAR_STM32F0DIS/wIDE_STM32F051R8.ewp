# IAR project wIDE_STM32F051R8.ewp, settings and files
configuration STM32F0DIS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\; ..\..\Boss
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wIDE_STM32F051R8.srec
  ILINK.IlinkOutputFile: wIDE_STM32F051R8.out
  ILINK.IlinkIcfFile: stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boss files
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM0_IAR.c Boss_CPU_ARM_CM0_IAR_asm.s
  group Source files
    ../../: Main.c
    ./: startup_stm32f0xx.s
    ../: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c system_stm32f0xx.c
