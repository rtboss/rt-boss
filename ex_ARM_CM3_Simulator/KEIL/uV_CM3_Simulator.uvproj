# Keil uVision project uV_CM3_Simulator.uvproj, settings and files
target Simulator (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: uV_CM3_Simulator
  c flags: Optim=1
  c include: ..\..\Boss;..\..\ex_ARM_CM3_Simulator
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Boss files
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM3_Keil.c
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_Tmr.c Boss_SPY.c
  group Source files
    ./: startup_ARMCM3.s
    ../: system_ARMCM3.c
    ../../: Main.c
