<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\wIDE_CM3_Simulator.ewp</path>
  </project>
  <batchBuild/>
</workspace>


