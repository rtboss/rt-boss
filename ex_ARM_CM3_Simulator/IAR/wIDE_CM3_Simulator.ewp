# IAR project wIDE_CM3_Simulator.ewp, settings and files
configuration Simulator (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Boss; ..\..\ex_ARM_CM3_Simulator
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wIDE_CM3_Simulator.srec
  ILINK.IlinkOutputFile: wIDE_CM3_Simulator.out
  ILINK.IlinkIcfFile: Simulator_ARMCM3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boss files
    ../../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_SPY.c Boss_Tmr.c
    ../: Boss_Conf.c
    ../../Boss_Port/: Boss_CPU_ARM_CM3_IAR.c Boss_CPU_ARM_CM3_IAR_asm.s
  group Source files
    ../../: Main.c
    ./: startup_ARMCM3.s
    ../: system_ARMCM3.c
